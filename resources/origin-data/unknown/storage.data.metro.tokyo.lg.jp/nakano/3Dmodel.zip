Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010], ExchangeRequirement[Architecture]
Time: 2024-02-16T13:37:57
Author: WongsakornWinner
Written by: EDMsix Version 602.28.129 Aug 2 2022
Made in: Autodesk Civil 3D 2024 - 日本語 (Japanese) Build 13.6.342.0
Comment: STEP Physical File produced by: EDMsix Version 602.28.129 Aug 2 2022 * Module: EDMstepFileFactory v4.0.1/EDMstandAlone * Creation date: 20240216 13:37:57 * Host: lap-jp-014-win * Database: C:\Users\WONGSA~1\AppData\Local\Temp\ACAIFCTMP/EDM28012\aec_ifc_db * Database version: 6007 * Database creation date: Fri Feb 16 13:28:27 2024 * Schema: IFC2X3 * Model: DataRepository.AecIfc * Model creation date: Fri Feb 16 13:37:56 2024 * Header model: DataRepository.AecIfc_Header * Header model creation date: Fri Feb 16 13:37:56 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 10522 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, aaa
LongName: nakano_20F_Restrant_Scan_Room1_latest2
ADT_Pset_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: Standard; ACA_DISPLAY_SET_ON_EXPORT: Model

# IfcBuilding, nakano_20F_Restrant_Scan_Room1_latest2
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingUse - VacancyRateInCategoryNow: 0; VacancyRateInCategoryFuture: 0
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0
